# Keil uVision project Project.uvprojx, settings and files
target megaphone (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: .\axf2bin.BAT
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL
  c misc: --C99
  c include: ../;../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;..\..\..\USER;..\..\..\USER\Bsp;..\..\..\USER\HARDWARE;..\..\..\USER\Hwos;..\..\..\USER\Include;..\..\..\USER\SYS;..\..\..\USER\ZKRT;..\..\..\USER;..\..\..\USER\FATFS\exfuns;..\..\..\USER\FATFS\src;..\..\..\USER\WAV;..\..\..\USER\COMMON
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../../USER/: main.c stm32f4xx_it.c
  group CMSIS
    ../../../USER/: system_stm32f4xx.c
  group Doc
    ../../../document/: readme.txt
    ./: axf2bin.BAT
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_dma2d.c stm32f4xx_pwr.c stm32f4xx_wwdg.c stm32f4xx_fmpi2c.c stm32f4xx_spi.c stm32f4xx_hash.c stm32f4xx_ltdc.c stm32f4xx_dfsdm.c stm32f4xx_dbgmcu.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_cryp.c stm32f4xx_flash_ramfunc.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_aes.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_cryp_des.c stm32f4xx_i2c.c stm32f4xx_spdifrx.c stm32f4xx_usart.c stm32f4xx_sai.c stm32f4xx_crc.c stm32f4xx_rng.c misc.c stm32f4xx_fsmc.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_dac.c stm32f4xx_lptim.c stm32f4xx_can.c stm32f4xx_dcmi.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_hash_md5.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_hash_sha1.c stm32f4xx_fmc.c
  group /MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group HW
    ../../../USER/HARDWARE/: can.c key.c led.c sdio_sdcard.c myiic.c wm8978.c i2s.c
  group HWOS
    ../../../USER/Hwos/: osqtmr.c ostmr.c ostmr0.c ostmr1.c osusart.c osusartX.c
  group ZKRT
    ../../../USER/ZKRT/: appaudio.c appcan.c light.c zkrt.c appupload.c recorder.c appfiles.c appaudio_handle.c
  group SYS
    ../../../USER/SYS/: sys.c usart.c
  group INCLUDE
    ../../../USER/Include/: hw_config.h port.h
  group BSP
    ../../../USER/Bsp/: BSP.c
  group FATFS
    ../../../USER/FATFS/exfuns/: exfuns.c fattester.c cc936.c
    ../../../USER/FATFS/src/: diskio.c ff.c
  group WAV
    ../../../USER/WAV/: wavplay.c
  group COMMON
    ../../../USER/COMMON/: malloc.c
software components: CMSIS:CORE 5.0.1
